# Repository benpeart/ada

File README.md:

# Ada
A friendly balancing robot

# MVP Features
* Cute - call it Ada (Lovelace)
* Two wheeled balancing robot
* Drive with a game controller
# V.Next Features
* Track person and follow them around
* Face recognition – “Hi Mom!”
* speak name, verbal interface (integrate with CoPilot/ChatGPT?)
* WebUI that allows manual navigation (virtual joystick and object avoidance)
* WebUI that shows LIDAR map with ability to tell them to go to a specific location

## KiCad design PCB/pendulumRobotModule.kicad_pcb

File PCB/README.md (part):

This folder contains KiCad (5.0.0) design files for the BalancingRobot PCB. 

# Features
* Supports both DRV8825 and A4988 based stepper drivers. Also works with TMC2100, resulting in a very silent robot
* Supported voltage: ~7 - 24V (2-6S LiPo/Li-ion)
* Digital current control of steppers (you'll need to desolder the potmeter and add a wire)
* Dynamic microstep switching, allowing for insane speeds
* Connections: 
	- Digital RC receiver (I use IBus / FlySky protocol), J5 upper row
	- Servo, J5 middle row. In case you want to add an arm for self righting :).
	- Digital LED (Neopixel / WS2812B etc), J5, lower row
	- All unused ESP32 pins are broken out (including I2C), for further use and development (J2)
	- Power input (J3). Allows for both a screw clamp and direct wire soldering. I prefer the last, given the high power output of a LiPo in case something comes loose.
* Wireless parameter tuning and data plotting. Makes tuning the controllers a lot easier
* Websocket communication for real-time communication between ESP32 and browser
* Web interface via access point / WiFi network. SSID and key can be set via web interface.

# Assembly
Assembly is quite straightforward. For those who like some instructions, here goes. For the ones that don't like to follow instructions: that's ok, but please read the last instruction about adjusting the buck converter voltage.

1. Start with the SMD components on the bottom side. First, pre-tin one pad, then place the SMD component while reheating the first pad. Finally, solder the second pad. C5 is not mounted.
2. Next, mount the voltage regulator module U3. The PCB accepts multipe kinds. 
3. Place the IMU (U2) with the angled male and female headers. Make sure that the IMU is rigidly mounted. If you don't, the IMU might for example vibrate during operation, causing unstable behaviour. See below pictures for clarification.
4. Add all female headers (J1, J4, J7, and for the stepper driver and ESP32 modules). Optionally, place some headers on J5 and J2 if you like.
5. Finally, place C2, C4 and F1.

IMPORTANT: when using an adjustable voltage regulator, adjust the voltage regulator to 5V BEFORE inserting any modules. By default, the voltage regulator is set to a higher voltage, and if you don't adjust it, you'll fry some components. 

IMU mounting

In the end, the PCB should look something like this

## Version 1.3 onwards
Some points of attention:
* The negative lead/cathode/side with flat edge of the LED should go in the *square* hole. The notch on the silkscreen is confusing
* The buck converter supplied in some kits should be mounted as seen in the picture below

## Advanced
Some optional improvements are listed here, which are not required for basic operation. 

You can de-solder the current adjustment potentiometer on the stepper driver breakout boards. Add a wire to the wiper terminal, and connect the (two) wires to J4. Current can then be adjusted via the web interface. Or, get creative, and implement some current saving functionality.

For better performance, you can tie the decay mode pin of the DRV8825 to VCC, setting it in fast mode. The DRV8825 sometimes skips steps in slow/mixed decay mode. Below picture illustrates both improvements.

## Auxiliary header
Connector J2 has a grid of 12 pins (3x4), with some general pins broken out, together with all unused ESP32 IO pins. See the close-up of the header below. Pin numbering in this picture is used in the table below to identify pins.

| Pin # | Name    | ESP32 pin |
|-------|---------|-----------|
| 1     | 5V      | Vin       |
| 2     | IMU_SCL | D22       |
| 3     | IMU_SDA | D21       |
| 4     | GND     | GND       |
| 5     | AUX1    | D32       |
| 6     | AUX2    | D33       |
| 7     | GND     | GND       |
| 8     | AUX3    | D35       |
| 9     | AUX4    | D26       |
| 10    | VCC     | 3V3       |
| 11    | AUX5    | D39       |
| 12    | AUX6    | D36       |

Note: as of PCB version v1.4 AUX2 and AUX4 are connected to the two LEDs that can function as "eyes".

# BOM
Applicable for v1.3 and onwards. 

| Qty | Reference(s)           | Value                                    |
|-----|------------------------|------------------------------------------|
| 2   | A1, A2                 | DRV8825 / A4988 stepper driver breakout  |
| 2   | C1, C3                 | 1u capacitor, 0805 SMD                   |
| 2   | C2, C4                 | 100u elco                                |
| 1   | C5                     | 100n capacitor, not placed               |
| 1   | C6                     | elco, not placed (e.g. for Neopixels)    |
| 1   | C7 	                   | 10uF 50V 1206, only placed if U4 is used |
| 1   | C8 	                   | 22uF 10V 0805, only placed if U4 is used |
| 2   | D1, D2 	               | 5mm LED, optional  					  |
| 1   | F1                     | Polyfuse                                 |
| 1   | J1                     | Female header, cut to size               |
| 1   | J2                     | N/A, solder whatever you like here       |
| 1   | J3                     | Screw terminal, or solder wires directly |
| 2   | J4, J7                 | 4 pin (fe)male header, cut to size       |
| 1   | J5                     | Male header, cut to size                 |
| 6   | R1, R2, R3, R4, R6, R7 | 3k3 resistor, 0805 SMD                   |
| 1   | R5                     | 100k resistor, 0805 SMD                  |
| 1   | SW1                    | (slider) switch, I use SS12D10           |
| 1   | U1                     | ESP32 devKit module, 30 pins             |
| 1   | U2                     | MPU6050 breakout, 8 pins                 |
| 1   | U3                     | Buck converter module                    |
| 1   | U4                     | Switching regulator 7805 compatible      |

Note: for U3, U4 place either of the two. I added two footprints to maximize compatibility. Examples for U4: MP-K7805-500R3, Recom r-78e5.0-0.5, MP-K78L05-1000R3

Additionally, you'll need a pair of 8 pin male/female angled headers, for mounting the IMU. For mounting the ESP32 and stepper driver modules, you'll need 2 times 15 and 16 pin female headers (4 in total).

Some examples of the modules:
* [ESP32 Devkit V1 module, 30 pins](https://www.aliexpress.com/item/ESP32-Development-Board-WiFi-Bluetooth-Ultra-Low-Power-Consumption-Dual-Core-ESP-32-ESP-32S/32802431728.html?spm=a2g0s.9042311.0.0.26604c4dM62q0I)
* [DRV8825 stepper driver](https://www.aliexpress.com/item/Free-shipping-10pcs-lot-3D-Printer-StepStick-DRV8825-Stepper-Motor-Drive-Carrier-Reprap-4-layer-PCB/32292074706.html?spm=a2g0s.9042311.0.0.26604c4dM62q0I)
* [MPU6050 IMU](http://www.aliexpress.com/item/GY-521-MPU-6050-MPU6050-Module-3-Axis-analog-gyro-sensors-3-Axis-Accelerometer-Module/32340949017.html?spm=a2g0s.9042311.0.0.26604c4dM62q0I)
* [Buck converter](https://www.aliexpress.com/item/10PCS-Mini-3A-DC-DC-Converter-Step-Down-Module-Adjustable-3V-5V-16V-Power-for-RC/32639738406.html?spm=a2g0s.9042311.0.0.66ef4c4duolobi)
* [Power switch](https://www.aliexpress.com/item/1005003079561856.html?spm=a2g0o.order_list.0.0.46e418027JRX4A)

# Issues
For PCB version 1.0, the + and - signs of the RX/Servo/LED indicator are swapped. The pinout is correct though. To be clear, the order (from right to left) is -, +, and signal. This has been solved in v1.1.

# Change history
## v1.0 
Initial version
## v1.1
* Increased track width of 5V and 24V traces
* Added second via in 24V trace, or rather added trace to second via which wasn't there in v1.0
* Swapped + and - symbols on silkscreen close to RX header 
* Added a 10k pull-up on the stepper driver enable. In v1.0, no pull-up is present, meaning the steppers are enabled if the ESP32 isn't running. No big deal, but somewhat neater to disable steppers if the ESP32 isn't running.
## v1.2
* Added optional 100k RX pulldown resistor
* Added optional 5V filtering cap (might be useful if for example some Neopixels are connected to 5V line)

Parts:
A1, A2: Pololu_Breakout_DRV8825; DRV8825-breakout
C1, C3: 1u; C_0805_2012Metric
C2, C4: 100u; CP_Radial_D8.0mm_P2.50mm
C5: 100n; C_0805_2012Metric
C6: 470u; CP_Radial_D6.3mm_P2.50mm
C7: 10u 50V; C_1206_3216Metric
C8: 22u 10V; C_0805_2012Metric
D1, D2: LED; LED_D5.0mm_Horizontal
F1: Polyfuse; polyfuse-5.08mm
J1: Conn_01x02_Female; Socket_Strip_Straight_1x02_Pitch2.54mm
J2: conn_3x4; pinHeader_3x4
J3: Conn_01x02_Male; wirePad-2x-2mm
J4, J7: Conn_01x04_Female; Socket_Strip_Straight_1x04_Pitch2.54mm
J5: conn_3x3; pinHeader_3x3
J6: Conn_01x02_Male; pinHeader_2x1_5.08mm
J8: Conn_01x02_Male; JST_XH_S02B-XH-A-1_1x02_P2.50mm_Horizontal
JP1: Jumper; GS2
R1, R2, R3, R4, R6, R7: 3k3; R_0805_2012Metric
R5, R8, R9, R10: 100k; R_0805_2012Metric
SW1: SW_SPDT; switch_slider_SPDT
U1: ESP32-devKit; ESP32-devkit-30p
U2: MPU6050-breakout; MPU6050-breakout-angledHeader
U3: buckConverter-adj; buck-converter-adj
U4: R-78E5.0-0.5; Converter_DCDC_RECOM_R-78E-0.5_THT

Connections:
+5V: C6.1, C8.1, J2.1 (C1R1), J5.2 (C1R2), J5.5 (C2R2), J5.8 (C3R2), U1.30 (Vin), U3.3 (VOUT), U4.3 (OUT)
+24V: A1.8 (VMOT), A2.8 (VMOT), C2.1, C4.1, C7.1, F1.1, J6.1, R5.1, U3.2 (VIN), U4.1 (IN)
/AUX1: J2.5 (C2R2), U1.21 (ADC1_4/GPIO32)
/AUX3: J2.8 (C3R2), U1.20 (ADC1_7/GPI35)
/AUX5: J2.11 (C4R2), U1.18 (ADC1_3/GPI39)
/AUX6: J2.12 (C4R3), U1.17 (ADC1_0/GPI36)
/BATT_VOLT: C3.1, R5.2, R6.1, U1.19 (ADC1_6/GPI34)
/DAC1: R1.1, U1.23 (DAC1/ADC2_8/GPIO25)
/IBUS_RX: J5.3 (C1R3), R8.1, U1.6 (GPIO16/RX2)
/IMU_INT: U1.15 (GPIO23/MOSI), U2.8 (INT)
/IMU_SCL: J2.2 (C1R2), R4.2, U1.14 (GPIO22/SCL), U2.3 (SCL)
/IMU_SDA: J2.3 (C1R3), R3.2, U1.11 (GPIO21/SDA), U2.4 (SDA)
/LED_DATA: J5.9 (C3R3), U1.9 (GPIO18/SCK)
/SERVO_PWM: J5.6 (C2R3), U1.10 (GPIO19/MISO)
/motADir: A1.16 (DIR), U1.5 (GPIO4_/ADC2_0)
/motAStp: A1.15 (STEP), U1.8 (GPIO5)
/motBDir: A2.16 (DIR), U1.3 (GPIO15/ADC2_3)
/motBStp: A2.15 (STEP), U1.4 (GPIO2_/ADC2_2)
/motEn: A1.9 (~EN), A2.9 (~EN), R7.2, U1.25 (ADC2_7/GPIO27)
/uStep0: A1.10 (M0), A2.10 (M0), U1.26 (ADC2_6/GPIO14)
/uStep1: A1.11 (M1), A2.11 (M1), U1.27 (ADC2_5/GPIO12)
/uStep2: A1.12 (M2), A2.12 (M2), U1.28 (ADC2_4/GPIO13)
GND: A1.1 (GND), A1.7 (GND), A2.1 (GND), A2.7 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), D2.1 (K), J2.4 (C2R1), J2.7 (C3R1), J3.2, J5.1 (C1R1), J5.4 (C2R1), J5.7 (C3R1), J6.2, J8.1, R2.2, R6.2, R8.2, U1.2 (GND), U1.29 (GND), U2.2 (GND), U3.1 (GND), U3.4 (GND), U4.2 (GND)
unnamed: A1.4 (A1), J4.2
unnamed: A1.3 (A2), J4.1
unnamed: A1.5 (B1), J4.3
unnamed: A1.6 (B2), J4.4
unnamed: A2.4 (A1), J7.2
unnamed: A2.3 (A2), J7.1
unnamed: A2.5 (B1), J7.3
unnamed: A2.6 (B2), J7.4
unnamed: D1.2 (A), R9.2
unnamed: D2.2 (A), R10.2
unnamed: C1.1, J1.1, J1.2, R1.2, R2.1
unnamed: J3.1, J8.2, SW1.2 (B)
unnamed: F1.2, SW1.3 (C)
unnamed: JP1.2, U2.7 (AD0)
VCC: A1.2 (~FLT), A1.13 (~RST), A1.14 (~SLP), A2.2 (~FLT), A2.13 (~RST), A2.14 (~SLP), C5.1, J2.10 (C4R1), JP1.1, R3.1, R4.1, R7.1, U1.1 (3V3), U2.1 (VCC)

Notes on the sheet:
Stepper motor current control
IMU
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

Board: 2 copper layers, 40.0 x 100.0 mm, 37 parts (15 on the bottom side), 40 nets.

## Commit log (part)

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2018-11-09 Add new file
2018-11-10 Add LICENSE
2018-11-10 Added PDF of schematic
2018-11-10 PCB updates: increased 24V trace thickness, added a via (or rather added trace to via) in that signal, and added stepper motor enable pull-up to 3V3.
2018-11-12 Slight update to FrameB: second screw hole for PCB was missing. Also, added a cut-out, such that the stepper motor can be mounted.
    Also, STL files have been added for 3D-printable parts.
2018-11-12 Changed 10uF cap to 1uF. Also, changed text on bottom layer to point to the correct reposityor.
2018-11-13 Updated readme for PCB
2018-11-14 Updated PCB readme.
2018-11-15 Somewhat improved IMU init. Also, closing #6, as this idea didn't seem to work: when moving the robot to an upright position, a relatively high acceleration is measured, causing the angle from accele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
2018-11-15 Updated software readme.
2018-11-15 Cleaned up IBus library, closing #5
2018-11-15 Implementation of mDNS. Both OTA and web page access are now much easier, no messing with IP addresses.
2018-11-16 Wireless related tasks now run on core 0, closing #7
2018-11-17 Fixing PCB readme pictures
2018-11-17 Image resizing
2018-11-21 Initial work on fully customisable, non-volatile, user changeable parameters!
2018-11-23 Making progress on parameter functions
2018-11-29 Progress on parameter setting library
2018-12-01 Still working on parameter lib
2018-12-03 Progress on par library
2018-12-14 Added IRAM_ATTR to stepper motor step function, solves crash during web page load. Closing #4
2018-12-15 Remote control via wifi working (well, the code is there, working is something else). Also, added activity detection to IBus library.
2018-12-15 Initial commit of control.htm (remote control via web page / wifi / websockets)
2019-01-27 Updated README.md Fixed max wifi-key-length to 63 chars. Replaced EEPROM-lib by Preferences-lib. You have to reenter all settings! Added pref_version. Now it is possible to increment pref_version to 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
2019-01-27 Updated webinterface: value-display for sliders settings rearranged larger wifi-textfields maxlength limitation on wifi-textfields
2019-01-27 Updated libs: MPU6050, I2Cdev
2019-02-03 Updated AsyncTCP and arduinoWebsockets libraries. Also, moved wireless tasks (IBus and wsServer) back to the main loop (core 1). While running on core 0, i2c issues were created due to the i2c bus be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
2019-02-03 Updated instructions for PCB (auxiliary header pinout), and some general instructions on stepper current adjustment and IMU calibration.
2019-02-07 PCB updated to version 1.2: added RX pulldown resistor and 5V buffer capacitor (both optional). Added some markings for buck converter. Web interface now has a fancy option for logging data (plotTest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
2019-02-08 Noise insertion implementation
2019-02-13 Some initial work on system identification in the frequency domain
2019-02-18 First system ID working. R parameter added to web interface (controls amount of setpoint used for error signal of PID controller)
2019-04-29 Added ace.js to ESP32 data folder. So far, when using access point to connect to robot, the /edit page wouldn't work, unless ace.js was previously cached. Now it should work fine.
2019-06-18 Added PPM-input Added speedFactor and steerFactor to set how strong it reacts to inputs Set default maxStepSpeed to 1500 Updated readme for stepper recommendation
2021-02-19 Initial simulation of system. Started with simple pendulum. Goal is to have a dynamical model of the system, such that I can simulate sensor behavior.
2021-02-19 Added initial simulation of moving robot!
2021-02-20 Fixed bug in y position of m2. Animation with rolling wheel (with spokes). Added fifth variable, which represents angle of wheel.
2021-02-24 Fix "streaming.h" not found error.
2021-03-01 Added feature which allows to drive with robot when it is lying down. Disabled microstepping as I'm now using TMC2100 drivers.
2021-03-01 Added some fancy simulation of the robot, work in progress
2021-03-01 Self-right and manual control are now working! Need to implement it properly
2021-03-24 Wifi control is working again, in some sort of hacky way
2021-03-26 Improved implmentation of overrideMode. Also, introduced new feature, to disable robot using remote input. Not perfect yet, but it is sure useful.
2021-04-09 Smooth transition from manual to automatic control (i.e. self-righting while in override mode) is now working. State machine (or something that should have been a state machine) now seems to be worki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
2021-04-10 Use pointer for changing pid settings
2021-04-17 Self righting / disable control is now working fine, for both IBus and webpage control
2021-04-17 Fixed bug in IBus code: if no receiver was connected, robot would still read speed command. IBus active flag is now set to true if a first message has been received.
2021-10-06 Added a new frame (frameC) which can house a 3S LiPo, and has improved robustness. Also it still self-rights with this frame.
2022-03-30 Implemented bluetooth control with cheap PS3 controller. Also, changed partition table, as new code (from PS3 controller) causes the default partition for code to be too small.
2022-04-06 Implemented PS3 controller a bit more neatly
2022-06-06 Updated some library dependencies, needed after update of Espressif IDF version in PlatformIO
2022-06-08 Implemented battery voltage readout. ADC is configured correctly, calibrated, and measured value is sent over to web page.
2022-06-08 Made robot name a configureable item in web interface
2022-06-08 Added partition table. Some small changes for handling serial commands
2022-06-10 Bluetooth MAC address is now printed correctly on startup
2022-06-10 Print message over serial port when bluetooth controller is connected
2022-06-10 Added simpletuning.htm, providing a simple web interface for tuning the position controller
2022-06-13 changed velocity presets
    lower linear speed
    increased rotational speed
    added offset control to adjust for asymmetric speed forward/reverse
2022-06-20 update web page formatting
    repaired tag and inserted <div> in the <body> to switch to style
2022-08-31 Implemented fall detection. If stepper motors are slipping, but robot doesn't react, the controller will disable itself.
2022-08-31 PCB v1.3 update. Added power switch, battery connector, and status LEDs.
2022-08-31 Some slight updates to PCB, also updated readme for PCB
2022-08-31 Some final touches on the PCB
2022-09-03 Some final touches to PCB / documentation of PCB
2022-10-19 Added LEDs in software. Small bugfix, self right sometimes not working correctly, fixed by reseting angle error integral after self right is complete.
2023-08-27 Updated PCB design files to Kicad 7. Added cut-out for stepper motor cable pass-through. Updated PCB version to v1.4. Connected LEDS to gpio 33 and 26, as old connections were used for USB TX/RX.
2023-09-22 Added compatibility for A4988 stepper driver, which has a somewhat different pattern for microstepping
2023-09-25 Added laser cut frame. Updated readme instructions for laser cut frame, PCB v1.4, and bluetooth control.
2023-09-25 Small updates to readmes
2023-10-07 Upload New File
2023-10-13 Fixed a bug in the serial interface. Updated documentation for calibrating/setting WiFi settings.
2023-10-13 Small updates for readability of readme
2023-10-13 Small addition to software readme
2024-09-14 Update to latest version of AsyncTCP and ESPAsyncWebServer Update to latest version of espressif32 platform Update fastStepper.cpp to support GPIO pins between 32 and 40 Add Xbox controller support A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
2024-09-14 Remove streaming library and use DB_PRINT* instead so our releases don't have all the debug info in them Remove FlySkyIBus code Remove motor current code (will use the TMC2209 library if it is needed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
2024-09-15 Big refactoring to pull code out of main.cpp. Moved all WebUI into webui.h/cpp Moved PS3 input code into ps3.h/cpp Moved Xbox input code into xbox.h/cpp Added favicon.ico for WebUI
2024-09-15 in plotTest.htm, open a web socket on load and disconnect to make it more robust fix a bug that prevented plotting from working by externing a single plot structure in globals.h Call Xbox_setup() so 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
2024-09-17 Remove lots of unused files from the original project. Replace with Ada specific files where needed.
2024-09-17 Update web pages to be Ada versions. Still have tuning and control pages to update.
2024-09-18 Now have Home, Settings, Control, Tune, Credits pages Home - pretty picture of Ada with links to other pages Settings - let you sent the robot name, wifi settings, stepper settings, calibrate gyro an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
2024-09-19 Update WiFi logic so that it will reconnect if it ever disconnects. Add battery voltage logic for when we add that to the PCB. Move bluetooth address variable into ps3.cpp as nothing else needs it.
2024-09-27 Add the TMCStepper library to enable controlling the features of the TMC2209 like CoolStep to save 75% energy and StealthChop to make the stepper motors silent at low speed. Replace the LED logic wit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
2024-09-27 More code refactoring. Split out the MPU6050 gyroscope code into separate gyro.h/cpp files.
2024-10-26 Remove the unused overrideMode/lastOverrideMode logic as it was never set to true
2024-10-28 Enable removing AsyncWebServer and WebSocketsServer from builds as they are only needed during development.
2024-11-06 Split up webserver and wifi/ota so we can remove the webserver from release builds as it is only needed for development/setup. Enable battery support as we have it in the latest PCB
2024-11-06 Update pin assignments to match the V2 hardware.
    NOTE: The TMC2209 code is currently not functional with V2 hardware.
2024-11-11 Add support for LEDs available in the new V2 hardware.
2024-11-12 Add picture of working prototype
2024-11-15 Remove the unused 'override' mode.
2024-11-16 Lower PID_SPEED_MAX so we are less likely to flip over with extreme accel/decel commands. Remove unused "ANGLE_ONLY" controlType. Change "Xbox connected" LED to be RED/GREEN to reflect connectivity.
    Implement a Finite State Machine to track balancing state changes. The following
    states and conditions are currently supported.
    Current State Next State Event/Condition
    ====================================================================
    Disabled Position Robot is standing
    Disabled Self Right Self right command
2024-11-16 Update Ada EasyEDAPro file with the V2 hardware design. Update the #SP32 pin assignments to match the V2 hardware. Update the (unused) Amplifier Design Notes.
2024-11-21 Output finite state machine changes in DEBUG mode Only transition states if they actually change
    Add a battery LED that shows green if "healthy," yellow if low and red if critical.
    Add logic to detect if we are running via USB or the battery.
    If powered by the battery, added logic to automatically disable Ada and enter deep sleep mode to prevent damaging a critically low battery.
2024-11-23 Let the compiler generate default constructors where needed Fix some state transitions to deal with bugs: - standing up bot manually works front to back but not back to front - standing up bot manual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
2024-11-25 Major refactoring. - Move all variables out of main/global into the module that manages them. - Remove the old non-finite state machine code paths - Move the remaining balancing variables and functio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
    Add 2 more pink LEDs so they show up better.
    Move the balancing controller and logic into a separate task so that it is insulated from WiFi/Bluetooth/Controller stutters.
    This means the robot will still keep balancing when the controller connects/disconnects or the WiFi changes state/hiccups!
2024-12-02 Add Ada Fusion 360 file used to create the frame and wheels.
2024-12-19 Add a parabolic response curve to the steering control that will dampen the response curve around zero and ramp it up as you get more extreme on the controls. The net effect is that it is controllabl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
2024-12-25 Add a parabolic response (squared) curve to the steering control that will dampen the response curve around zero and ramp it up as you get more extreme on the controls. The net effect is that it is c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
